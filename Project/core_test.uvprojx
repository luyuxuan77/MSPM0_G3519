# Keil uVision project core_test.uvprojx, settings and files
target KEIL_M0G3519 (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: core_test +hex
  BeforeMake: cmd.exe /C "..\SysConfig\run_syscfg_prebuild.bat"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..\BSP;..\Source;..\Source\third_party\CMSIS\Core\Include;..\User
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  group BSP
    ../BSP/: bsp.h bsp_common.h
    ../BSP/UART0/: uart0.c
    ..//BSP//LED//: led.c
    ..//BSP//TimerG6_PWM_RGB//: timerG6_pwm_rgb.c
    ..//BSP//KEY//: key.c keypad.c
    ..//BSP//TimerA1//: timera1.c
    ..//BSP//SPI0_OLED//: spi0_oled.c
    ../BSP/ADC/: adc.c
    ../BSP/QEI/: qei.c
  group User
    ../User/: config.syscfg main.c menu.c ti_msp_dl_config.c ti_msp_dl_config.h
  group Source
    ../Source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_i2s.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_npu.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spgss.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerb.c dl_timerg.c dl_trng.c dl_uart.c dl_unicomm.c dl_unicommi2cc.c dl_unicommi2ct.c dl_unicommspi.c dl_unicommuart.c dl_vref.c dl_wwdt.c
    ../Source/ti/driverlib/m0p/: dl_factoryregion.c dl_interrupt.c
    ../Source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0gx51x.c
    ./: startup_mspm0g351x_uvision.s
