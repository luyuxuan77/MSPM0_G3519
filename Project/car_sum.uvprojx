# Keil uVision project car_sum.uvprojx, settings and files
target KEIL_M0G3519 (6240000::V6.24::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: car_sum +hex
  BeforeMake: C:\ti\mspm0_sdk_2_10_00_04\tools\keil\syscfg.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3519__
  c include: ..\BSP;..\Source;..\Source\third_party\CMSIS\Core\Include;..\BSP\IMU;..\BSP\IMU\LSM6DSV16X;..\BSP\GRAY;..\BSP\MOTOR;..\BSP\PID;..\BSP\TimerA1;..\BSP\UART0;..\BSP\KEY;..\BSP\LED;..\User;..\BSP\IMU\IMU;..\BSP\IMU;..\BSP\APP_INIT;..\BSP\CONTROL;..\BSP\INS;..\BSP\ROAD;..\User;..\BSP\Buzzer;..\BSP\PWM1_Shared;..\BSP\MENU
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  group BSP
    ../BSP/: bsp.h
    ../BSP/UART0/: uart0.c
    ../BSP/SPI0_LCD/: lcd.c lcd_init.c
    ../BSP/TimerA1/: TimerA1.c
    ../BSP/LED/: led.c
    ../BSP/SPI1/: spi1.c
    ../BSP/IMU/LSM6DSV16X/: lsm6dsv16x_read_data_polling.c lsm6dsv16x_reg.c lsm6dsv16x_sensor_fusion.c
    ../BSP/MOTOR/: motor.c
    ../BSP/MENU/: menu.c
    ../BSP/KEY/: key.c
    ../BSP/ADC0/: adc0.c
    ../BSP/PID/: pid.c
    ../BSP/GRAY/: gray.c
    ../BSP/IMU/IMU/: IMU.c
    ../BSP/IMU/: basic_read_reg.c
    ../BSP/APP_INIT/: app_init.c
    ../BSP/CONTROL/: control.c
    ../BSP/INS/: ins.c
    ../BSP/ROAD/: road.c
    ../BSP/Buzzer/: buzzer.c
    ../BSP/PWM1_Shared/: pwm1_shared.c
  group Source
    ../Source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_i2s.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_npu.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spgss.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerb.c dl_timerg.c dl_trng.c dl_uart.c dl_unicomm.c dl_unicommi2cc.c dl_unicommi2ct.c dl_unicommspi.c dl_unicommuart.c dl_vref.c dl_wwdt.c
    ../Source/ti/driverlib/m0p/: dl_factoryregion.c dl_interrupt.c
    ../Source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0gx51x.c
    ./: startup_mspm0g351x_uvision.s
  group User
    ../User/: config.syscfg main.c ti_msp_dl_config.c ti_msp_dl_config.h
